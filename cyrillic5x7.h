#ifndef _CYRILLIC5X7_H_
#define _CYRILLIC5X7_H_

#include <Adafruit_GFX.h>

// Вертикальні 5x7 бітові карти літер кирилиці
const uint8_t cyrillic5x7Bitmaps[][5] PROGMEM = {
  {0x00, 0x00, 0x00, 0x00, 0x00}, // 0: Пробіл
  {0x7C, 0x12, 0x11, 0x12, 0x7C}, // 1: А
  {0x7F, 0x49, 0x49, 0x49, 0x31}, // 2: Б
  {0x7F, 0x49, 0x49, 0x49, 0x36}, // 3: В
  {0x7F, 0x01, 0x01, 0x01, 0x03}, // 4: Г
  {0x70, 0x29, 0x29, 0x29, 0x7F}, // 5: Д
  {0x7F, 0x49, 0x49, 0x49, 0x41}, // 6: Е / Є
  {0x77, 0x08, 0x7F, 0x08, 0x77}, // 7: Ж
  {0x41, 0x49, 0x49, 0x49, 0x36}, // 8: З
  {0x7F, 0x10, 0x08, 0x04, 0x7F}, // 9: И / І
  {0x7F, 0x10, 0x09, 0x04, 0x7F}, // 10: Й
  {0x7F, 0x08, 0x14, 0x22, 0x41}, // 11: К
  {0x40, 0x3E, 0x01, 0x01, 0x7F}, // 12: Л
  {0x7F, 0x02, 0x0C, 0x02, 0x7F}, // 13: М
  {0x7F, 0x08, 0x08, 0x08, 0x7F}, // 14: Н
  {0x3E, 0x41, 0x41, 0x41, 0x3E}, // 15: О
  {0x7F, 0x01, 0x01, 0x01, 0x7F}, // 16: П
  {0x7F, 0x09, 0x09, 0x09, 0x06}, // 17: Р
  {0x3E, 0x41, 0x41, 0x41, 0x22}, // 18: С
  {0x01, 0x01, 0x7F, 0x01, 0x01}, // 19: Т
  {0x0F, 0x40, 0x40, 0x40, 0x3F}, // 20: У
  {0x1E, 0x21, 0x7F, 0x21, 0x1E}, // 21: Ф
  {0x63, 0x14, 0x08, 0x14, 0x63}, // 22: Х
  {0x7F, 0x40, 0x40, 0x40, 0x7F}, // 23: Ц
  {0x07, 0x08, 0x08, 0x08, 0x7F}, // 24: Ч
  {0x7F, 0x40, 0x7F, 0x40, 0x7F}, // 25: Ш
  {0x7F, 0x40, 0x7F, 0x40, 0xFF}, // 26: Щ
  {0x01, 0x7F, 0x48, 0x48, 0x30}, // 27: Ъ
  {0x7F, 0x48, 0x30, 0x00, 0x7F}, // 28: Ы / Ї
  {0x7F, 0x48, 0x48, 0x30, 0x00}, // 29: Ь
  {0x22, 0x41, 0x49, 0x49, 0x3E}, // 30: Э
  {0x7F, 0x08, 0x3E, 0x41, 0x3E}, // 31: Ю
  {0x46, 0x29, 0x19, 0x09, 0x7F}  // 32: Я
};

// Попіксельне малювання символу
void drawCyrillicChar(Adafruit_GFX &gfx, int index, int16_t x, int16_t y, uint8_t size) {
  for (int col = 0; col < 5; col++) {
    uint8_t line = pgm_read_byte(&cyrillic5x7Bitmaps[index][col]);
    for (int row = 0; row < 7; row++) {
      if (line & (1 << row)) {
        if (size == 1) {
          gfx.drawPixel(x + col, y + row, SSD1306_WHITE);
        } else {
          gfx.fillRect(x + col * size, y + row * size, size, size, SSD1306_WHITE);
        }
      }
    }
  }
}

// Друк текстового рядка
void printCyrillic(Adafruit_GFX &gfx, String text, int16_t x, int16_t y, uint8_t size = 1) {
  int16_t curX = x;
  int16_t curY = y;

  for (size_t i = 0; i < text.length(); i++) {
    uint8_t c = text[i];

    if (c == '\n') {
      curX = x;
      curY += 8 * size;
      continue;
    }

    if (c == 0xD0 || c == 0xD1) {
      i++;
      if (i >= text.length()) break;
      uint8_t c2 = text[i];
      int index = 0;

      if (c == 0xD0 && c2 >= 0x90 && c2 <= 0xAF) index = (c2 - 0x90) + 1;       // А-Я
      else if (c == 0xD0 && c2 >= 0xB0 && c2 <= 0xBF) index = (c2 - 0xB0) + 1; // а-п
      else if (c == 0xD1 && c2 >= 0x80 && c2 <= 0x8F) index = (c2 - 0x80) + 17;// р-я
      else if (c == 0xD0 && (c2 == 0x86 || c2 == 0x87)) index = 9;             // І, Ї
      else if (c == 0xD1 && (c2 == 0x96 || c2 == 0x97)) index = 9;             // і, ї
      else if (c == 0xD0 && c2 == 0x84) index = 6;                             // Є
      else if (c == 0xD1 && c2 == 0x94) index = 6;                             // є

      if (index >= 1 && index <= 32) {
        drawCyrillicChar(gfx, index, curX, curY, size);
      } else {
        drawCyrillicChar(gfx, 0, curX, curY, size);
      }
      curX += 6 * size;
    } else {
      gfx.setTextSize(size);
      gfx.setCursor(curX, curY);
      gfx.write(c);
      curX += 6 * size;
    }
  }
}

#endif